# Keil uVision project LCD.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LCD
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: ST7066U_LCD.c main.c
  group ::Device
    RTE/Device/TM4C123GH6PM/: CU_system_TM4C123.c CU_system_TM4C123.h startup_TM4C123.s
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
