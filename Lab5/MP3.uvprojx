# Keil uVision project MP3.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.0.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MP3
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c ST7066U_LCD.c mci.c spi.c i2c.c player.c rt_uart.c sta_config_file.c sta013.c uart.c dma.c gui.c
  group FatFs
    ./fatfs/: diskio.c ff.c
    ./fatfs/option/: unicode.c syscall.c
  group ::CMSIS
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/4.2.0/CMSIS_RTX/LIB/ARM/: RTX_CM4.lib
    RTE/CMSIS/: RTX_Conf_CM.c
  group ::Device
    RTE/Device/TM4C123GH6PM/: CU_system_TM4C123.c CU_system_TM4C123.h startup_TM4C123.s
software components: CMSIS:CORE 3.40.0, CMSIS:RTOS:Keil RTX 4.75.0, Device:Startup 1.0.0
